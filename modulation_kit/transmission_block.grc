<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>transmission_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>m_qam_order</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mod_type</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>str_len</value></param>
<param><key>value</key><value>22</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>upsampling_factor</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_1_0</value></param>
<param><key>amp</key><value>0.5</value></param>
<param><key>freq</key><value>100000</value></param>
<param><key>minoutbuf</key><value>1048576</value></param>
<param><key>offset</key><value>0.5</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_SIN_WAVE</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_1</value></param>
<param><key>file</key><value>D:\iiitd\gnu_files\modulation_kit\tx_out</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_1_0</value></param>
<param><key>file</key><value>D:\iiitd\gnu_files\modulation_kit\dc_arr</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>C:\Users\saans\Desktop\text_message.txt</value></param>
<param><key>minoutbuf</key><value>1048576</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>minoutbuf</key><value>1048576</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_0</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
import matplotlib.pyplot as plt
import scipy
from gnuradio import gr


class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """Embedded Python Block example - a simple multiply const"""

    def __init__(self, string_len=1,mod_type = 3, interpolation = 5,m_qam=4):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.sync_block.__init__(
            self,
            name='Modulation Python Block',   # will show up in GRC
            in_sig=[np.uint8,np.float32],
            out_sig=[np.complex64,np.complex64,np.complex64]
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        self.string_len = string_len
        self.set_history(2)    
        self.mod_type = mod_type 
        self.interpolation = interpolation
        self.set_min_output_buffer(2**20)
        self.m_qam = m_qam

    mapping_table = {
        (0,0) : -1 + 1j,
        (0,1) :  1 + 1j,
        (1,0) : -1 - 1j,
        (1,1) :  1 - 1j
    }

    mapping_table_8 = {
        (0,0,0) : -3+1j,
        (0,0,1) : -1+1j,
        (0,1,0) :  3+1j,
        (0,1,1) :  1+1j,
        (1,0,0) : -3-1j,
        (1,0,1) : -1-1j,
        (1,1,0) :  3-1j,
        (1,1,1) :  1-1j
    }

    mapping_table_16 = {
        (0,0,0,0) : -3+3j,
        (0,0,0,1) : -1+3j,
        (0,0,1,0) : -3+1j,
        (0,0,1,1) : -1+1j,
        (0,1,0,0) : -3-3j,
        (0,1,0,1) : -1-3j,
        (0,1,1,0) : -3-1j,
        (0,1,1,1) : -1-1j,
        (1,0,0,0) :  3+3j,
        (1,0,0,1) :  1+3j,
        (1,0,1,0) :  3+1j,
        (1,0,1,1) :  1+1j,
        (1,1,0,0) :  3-3j,
        (1,1,0,1) :  1-3j,
        (1,1,1,0) :  3-1j,
        (1,1,1,1) :  1-1j
    }

    demapping_table = {v : k for k, v in mapping_table.items()}

    demapping_table_8 = {v : k for k, v in mapping_table_8.items()}

    demapping_table_16 = {v : k for k, v in mapping_table_16.items()}

    def ofdm_config(self,bits_arr):
        m = np.log2(self.m_qam).astype(int)
        ##S/P
        rem = len(bits_arr)%m
        bits_arr = np.append(bits_arr,np.zeros(m-rem))
        bits = bits_arr.reshape((len(bits_arr)//m, m))            
        #print(bits_arr)
        ##QAM-Mod
        QAM = []
        if(self.m_qam == 4):
            QAM = np.array([self.mapping_table[tuple(b)] for b in bits])
        elif(self.m_qam == 8):
            QAM = np.array([self.mapping_table_8[tuple(b)] for b in bits])
        elif(self.m_qam == 16):
            QAM = np.array([self.mapping_table_16[tuple(b)] for b in bits])
        #print(QAM.shape)
        N = 64
        if(QAM.size &lt; 62):
            dummy = np.zeros(62).astype(complex)
            if(self.m_qam == 4):
                dummy[:] = -1 + 1j
            elif(self.m_qam == 8):
                dummy[:] = -3 + 1j
            elif(self.m_qam == 16):
                dummy[:] = -3 - 3j
            dummy[:len(QAM)] = QAM
            QAM = dummy

        elif(QAM.size %((N/2)-1) !=0 ):
            val = ((N/2)-1) - (QAM.size %((N/2)-1))
            dummy = np.zeros(val).astype(complex)
            if(self.m_qam == 4):
                dummy[:] = -1 + 1j
            elif(self.m_qam == 8):
                dummy[:] = -3 + 1j
            elif(self.m_qam == 16):
                dummy[:] = -3 - 3j
            QAM = np.append(QAM,dummy)

        l = len(QAM)
        a = (int) ((N/2) - 1)
        b = (int) ( l/((N/2)-1) )
        inp = np.reshape(QAM, (a,b))
        return QAM,inp,a,b



    def work(self, input_items, output_items):
        
        data = []
        bits_arr = []
        final_out = []
        carrier_sig = input_items[1]
        cond = True
        
        if(input_items[0][0] == 0):
            data = input_items[0][1:1+self.string_len]
            bits_arr = np.zeros(self.string_len*8).astype(int)

            for i in range(0,len(data)):
                bits_arr[i*8:(i*8)+8] = np.unpackbits(np.uint8(data[i]))
            ##Generating-Sync-Bits-Block.
            sync_bits = [1, 1, 1, 1, 1, 0, 0, 1, 1, 0, 1, 0, 1]
            out_sync_bits = np.repeat(sync_bits,2)
            gen_sync_bits = np.tile(out_sync_bits,2).reshape(-1,)
            ##Data-Stream-Mux
            stream_out = np.append(gen_sync_bits,bits_arr)
            ##Manchester-Coding-Block
            manch_input = []
            for i in range(0,len(stream_out)):
                if stream_out[i] == 0:
                    manch_input.append(1)
                    manch_input.append(0)
                else:
                    manch_input.append(0)
                    manch_input.append(1)
            manch_input = np.array(manch_input)
            ##Repeat/Interpolation
            final_out = np.repeat(manch_input,self.interpolation)
        
        else:
            output_items[1][:] = -1 + 1j
            cond = False

        if(self.mod_type == 0 and cond):
            ##OOK
            ook_mod_sig = []
            ook_mod_sig = carrier_sig[:len(final_out)]*final_out
            output_items[0][:len(ook_mod_sig)] = ook_mod_sig
            
            ##tx-out-size
            output_items[2][0] = len(ook_mod_sig)
        
        elif(self.mod_type == 1 and cond):
            ##DCO-OFDM 
            N = 64
            QAM,inp,a,b = self.ofdm_config(bits_arr)
            tx_out = np.zeros((N,b)).astype(complex)
            ##tx_out-size
            output_items[2][0] = N*b
            ##DC-size
            output_items[2][1] = b

            DC = np.zeros(b).astype(complex)
            temp = []

            ##Herm-prop
            for i in range(0,b):
                x = inp[:,i]
                x1 = np.append([0],x)
                x2 = np.append([0],np.flip(np.conj(x1)))
                x_herm = np.append(x1,x2)
                x2 = np.fft.ifft(x_herm,64)
                DC[i] = -np.min(x2)
                output_items[2][2+i] = DC[i] ##storing DC values.
                x_tx = x2 + DC[i]
                tx_out[:,i] = x_tx

            tx_out = tx_out.reshape((-1,))
            
            output_items[0][:len(tx_out)] = tx_out
            output_items[1][:len(QAM)] = QAM
            output_items[1][len(QAM):] = -1 + 1j

        
        elif(self.mod_type == 2 and cond):
            ##ACO-OFDM
            N = 124
            QAM,inp,a,b = self.ofdm_config(bits_arr)
            tx_out = np.zeros((N,b)).astype(complex)
            ##tx_out-size
            output_items[2][0] = N*b
            
            ##Herm-prop
            for i in range(0,b):
                x = inp[:,i]
                x_bar = np.append(x,np.flip(np.conj(x)))
                t = np.zeros(2*x_bar.size).astype(complex)
                t[1::2] = x_bar
                x_tx = np.fft.ifft(t)
                tx_out[:,i] = x_tx
            print(tx_out.shape)
            tx_out = tx_out.reshape((-1,))
            
            output_items[0][:len(tx_out)] = tx_out
            output_items[1][:len(QAM)] = QAM
            output_items[1][len(QAM):] = -1 + 1j

        elif(self.mod_type &gt;= 3):
            print("Wrong input.")

        
        #print(output_items[0][output_items[0] &gt;= 0].size)
        return len(output_items)
</value></param>
<param><key>interpolation</key><value>upsampling_factor/2</value></param>
<param><key>m_qam</key><value>m_qam_order</value></param>
<param><key>mod_type</key><value>mod_type</value></param>
<param><key>string_len</key><value>str_len</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>gui_hint</key><value>tab@1</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>5</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0</value></param>
<param><key>gui_hint</key><value>tab@0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>1000</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>5</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tab</value></param>
<param><key>label0</key><value>Modulated Signal</value></param>
<param><key>label1</key><value>Constellation</value></param>
<param><key>num_tabs</key><value>2</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_1_0</source_block_id><sink_block_id>epy_block_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>epy_block_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_0</source_block_id><sink_block_id>blocks_file_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_0</source_block_id><sink_block_id>blocks_file_sink_1_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
</flow_graph>
